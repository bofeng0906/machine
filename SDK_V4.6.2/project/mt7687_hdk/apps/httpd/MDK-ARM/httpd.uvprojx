# Keil uVision project httpd.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MT7687F MediaTek
  pack: MediaTek.MTx.4.6.2
  cpu: IROM(0x10000000,0x00200000) IRAM(0x20000000,0x00040000) IRAM2(0x00100000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: httpd +hex
  AfterMake: fromelf.exe --bin -o $L@L.bin #L
  AfterMake: fromelf.exe -c -o $L@L.dis #L
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: PCFG_OS=2 _REENT_SMALL MTK_SYS_TRNG_ENABLE  MTK_MINISUPP_ENABLE MTK_SMTCN_ENABLE MTK_BSP_LOAD_WIFI_PROFILE_ENABLE MTK_BSPEXT_ENABLE  MTK_HAL_LOWPOWER_ENABLE MTK_LWIP_ENABLE PRODUCT_VERSION=7687 MTK_FLASH_DIRECT_DL MTK_PATCH_DL_ENABLE   MTK_WIFI_WPS_ENABLE MTK_WIFI_REPEATER_ENABLE  CONFIG_REPEATER MTK_DEBUG_LEVEL_INFO MTK_DEBUG_LEVEL_WARNING MTK_DEBUG_LEVEL_ERROR MTK_NVDM_ENABLE
  c misc: --C99 --diag_suppress=161 --diag_suppress=1295
  c include: ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include;..\inc;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\..\kernel\rtos\FreeRTOS\inc;..\..\..\..\..\driver\CMSIS\Device\MTK\mt7687\Include;..\..\..\..\..\project\mt7687_hdk\test_cases\sys_init_test\inc;..\..\..\..\..\kernel\service\inc;..\..\..\..\..\middleware\third_party\lwip\src\include;..\..\..\..\..\driver\CMSIS\Include;..\..\..\..\..\middleware\third_party\lwip\ports\include;..\..\..\..\..\driver\chip\inc;..\..\..\..\..\driver\chip\mt7687\inc;..\..\..\..\..\middleware\MTK\dhcpd\inc;..\..\..\..\..\middleware\MTK\minicli\inc;..\..\..\..\..\middleware\MTK\minisupp\inc;..\..\..\..\..\prebuilt\middleware\MTK\minisupp\inc;..\..\..\..\..\driver\chip\inc;..\..\..\..\..\driver\chip\mt7687\src\common\include;..\..\..\..\..\driver\board\mt76x7_hdk\inc_private;..\..\..\..\..\middleware\third_party\lwip\src\include;..\..\..\..\..\middleware\third_party\lwip\ports\include;..\..\..\..\..\middleware\third_party\lwip\src\include\lwip;..\..\..\..\..\project\common\bsp_ex\inc;..\..\..\..\..\middleware\MTK\nvdm\inc;..\..\..\..\..\middleware\MTK\nvdm\src\portable;..\..\..\..\..\middleware\third_party\ping\inc;..\..\..\..\..\middleware\MTK\smtcn\inc;..\..\..\..\..\middleware\third_party\sntp\inc;..\..\..\..\..\middleware\third_party\httpd\inc;..\..\..\..\..\project\mt7687_hdk\apps\httpd\MDK-ARM\generate_file;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\RVDS\mt7687\port_tickless.h;..\..\..\..\..\driver\board\mt76x7_hdk\util\inc;..\..\..\..\..\middleware\MTK\wifi_service\combo\inc;..\..\..\..\..\driver\board\mt76x7_hdk\ept\inc;..\..\..\..\..\middleware\third_party\httpclient\inc;..\..\..\..\..\driver\board\mt76x7_hdk\external_flash\inc;..\..\..\..\..\middleware\MTK\connsys\inc;..\..\..\..\..\middleware\MTK\verno\inc
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x100000 size 0x10000
  scatter file: .\flash.sct
  link misc: --entry Reset_Handler --first __isr_vector --keep N9_array
  group board
    ../../../../../middleware/MTK/wifi_service/combo/src/: wifi_repeater.c wifi_cm4_scan.c inband_queue_option.c wifi_os_api.c get_profile_string.c misc.c wifi_wps.c wifi_profile.c
    ../../../../../prebuilt/middleware/MTK/wifi_service/combo/lib/wifi_supp/: libwifi_CM4_Keil.lib
    ../../../../../middleware/MTK/wifi_service/combo/src/wifi_os_ext/: os_utils.c os_util.c
    ../src/: ept_eint_var.c ept_gpio_var.c
    ../../../../../middleware/MTK/wifi_service/combo/src/init/: wifi_default_config.c wifi_init.c
  group driver
    ../../../../../driver/chip/mt7687/src/: hal_misc.c hal_adc.c hal_aes.c hal_cache.c hal_cache_internal.c hal_des.c hal_eint.c hal_flash.c hal_gdma.c hal_gpio.c hal_gpt.c hal_i2c_master.c hal_i2s.c hal_irtx.c hal_log.c hal_md5.c hal_pwm.c hal_rtc.c hal_sha.c hal_spi_master.c hal_uart.c hal_wdt.c hal_nvic.c hal_dwt.c
    ../../../../../driver/chip/mt7687/src/common/: cos_api.c dma.c flash_sfc.c gpt.c hal_gpc.c hal_gpio_7687.c hal_I2C.c hal_i2s_internal.c hal_irrx.c hal_lp.c hal_pcnt.c hal_pinmux.c hal_spim.c hal_sys.c hal_trng.c hal_uid.c i2c.c ir_tx.c low_hal_gpio.c low_hal_irrx.c low_hal_irtx.c low_hal_pwm.c low_hal_rtc.c low_hal_wdt.c nvic.c pinmux.c pwm.c sfc.c spi_flash.c spim.c timer.c top.c uart.c
    ../../../../../middleware/MTK/connsys/src/: connsys_util.c connsys_bus.c connsys_driver.c
    ../../../../../prebuilt/driver/chip/mt7687/lib/: libhal_protected_CM4_Keil.lib libhal_core_CM4_Keil.lib
    ../../../../../driver/board/mt76x7_hdk/ept/src/: bsp_gpio_ept_config.c
    ../../../../../driver/board/mt76x7_hdk/external_flash/src/: bsp_flash_config.c
  group rtos
    ../../../../../kernel/rtos/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/RVDS/mt7687/: port_tick.c
  group service
    ../../../../../kernel/service/src/: context_info_save.c exception_handler.c syslog.c toi.c os_port_callback.c
  group dhcpd
    ../../../../../middleware/MTK/dhcpd/src/: dhcpd.c
  group lwip
    ../../../../../middleware/third_party/lwip/ports/: ethernetif.c lwip_cli.c lwip_log.c pbuf.c sys_arch.c tcp_out.c
    ../../../../../middleware/third_party/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c pppapi.c sockets.c tcpip.c
    ../../../../../middleware/third_party/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c ip_frag.c ip4.c ip4_addr.c
    ../../../../../middleware/third_party/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../../../../../middleware/third_party/lwip/src/core/snmp/: asn1_dec.c asn1_enc.c mib_structs.c mib2.c msg_in.c msg_out.c
    ../../../../../middleware/third_party/lwip/src/core/: def.c dhcp.c dns.c inet_chksum.c init.c mem.c memp.c netif.c raw.c stats.c sys.c tcp.c tcp_in.c lwip_timers.c udp.c
    ../../../../../middleware/third_party/lwip/src/netif/ppp/polarssl/: arc4.c des.c md4.c sha1.c md5.c
    ../../../../../middleware/third_party/lwip/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c ppp.c pppcrypt.c pppoe.c pppos.c upap.c vj.c utils.c
    ../../../../../middleware/third_party/lwip/src/netif/: etharp.c slipif.c
  group minisupp
    ../../../../../prebuilt/middleware/MTK/minisupp/lib/: libminisupp_wps_CM4_Keil.lib
  group nvdm
    ../../../../../middleware/MTK/nvdm/src/: nvdm_port.c
    ../../../../../prebuilt/middleware/MTK/nvdm/lib/: libnvdm_CM4_KEIL.lib
  group apps
    ../src/: main.c regions_init.c system_mt7687.c sys_init.c wifi_lwip_helper.c network_default_config.c
    ./: startup_mt7687.s
    ../../../../../tools/keil/mt7687/N9/: mt76X7_n9_image.c
  group httpd
    ../../../../../middleware/third_party/httpd/src/: auth_check.c axhttpd.c base64.c cgi.c cgi_api.c httpd_api.c os_port.c proc.c tdate_parse.c web_proc.c
    ../../../../../middleware/third_party/httpd/web_c/: web__AP_html.c web__index_html.c web__Test_html.c web__Test1_html.c webpage.c
  group httpclient
    ../../../../../middleware/third_party/httpclient/src/: httpclient.c
