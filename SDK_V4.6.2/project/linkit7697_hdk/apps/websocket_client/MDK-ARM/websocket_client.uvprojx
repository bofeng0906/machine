# Keil uVision project websocket_client.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MT7687F MediaTek
  pack: MediaTek.MTx.4.6.2
  cpu: IROM(0x10000000,0x00400000) IRAM(0x20000000,0x00040000) IRAM2(0x00100000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: websocket_client
  AfterMake: fromelf.exe --bin -o $L@L.bin #L
  AfterMake: fromelf.exe -c -o $L@L.dis #L
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=1
  c define: MTK_WEBSOCKET_SSL_ENABLE PCFG_OS=2 _REENT_SMALL MTK_FLASH_DIRECT_DL MTK_PATCH_DL_ENABLE MTK_BSPEXT_ENABLE MTK_DEBUG_LEVEL_INFO MTK_HAL_LOWPOWER_ENABLE MBEDTLS_CONFIG_FILE=<config-mtk-websocket.h> MTK_EXTERNAL_FLASH_ENABLE USE_HAL_DRIVER PRODUCT_VERSION=7697 SUPPORT_MBEDTLS MTK_NVDM_ENABLE MTK_MINISUPP_ENABLE
  c misc: --c99
  c include: ..\..\..\..\..\kernel\rtos\FreeRTOS;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include;..\..\..\..\..\driver\CMSIS\Device\MTK\mt7687\Include;..\..\..\..\..\driver\CMSIS\Include;..\..\..\..\..\driver\chip\mt7687\inc;..\..\..\..\..\middleware\MTK\connsys\inc;..\..\..\..\..\driver\chip\inc;..\..\..\..\..\driver\chip\mt7687\src\common\include;..\..\..\..\..\middleware\MTK\minisupp\inc;..\..\..\..\..\prebuilt\middleware\MTK\minisupp\inc;..\..\..\..\..\middleware\third_party\nghttp2\lib\includes;..\..\..\..\..\middleware\third_party\nghttp2\lib\includes\nghttp2;..\..\..\..\..\middleware\third_party\xml\inc;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\..\kernel\service\inc;..\..\..\..\..\middleware\MTK\nvdm\inc;..\..\..\..\..\middleware\MTK\wifi_service\combo\inc;..\..\..\..\..\driver\board\linkit7697_hdk\util\inc;inc;..\inc;src\common\include;..\..\..\..\..\kernel\service\inc;..\..\..\..\..\driver\board\linkit7697_hdk\external_flash\inc;driver\board\linkit7697_hdk\external_flash\driver\board\linkit7697_hdk\external_flash\inc;..\..\..\..\..\driver\chip\inc;..\..\..\..\..\driver\board\mt76x7_hdk\inc;..\..\..\..\..\driver\chip\mt7687\src\common\include;..\..\..\..\..\driver\chip\mt7687\inc;..\..\..\..\..\kernel\service\inc;..\..\..\..\..\driver\chip\inc;..\..\..\..\..\driver\board\mt76x7_hdk\inc;..\..\..\..\..\driver\chip\mt7687\src\common\include;..\..\..\..\..\driver\chip\mt7687\inc;..\..\..\..\..\kernel\service\inc;..\..\..\..\..\driver\board\linkit7697_hdk\ept\inc;..\..\..\..\..\middleware\util\include;..\..\..\..\..\middleware\MTK\minicli\include;..\..\..\..\..\kernel\rtos\FreeRTOS\include;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\..\kernel\rtos\FreeRTOS\Source;..\..\..\..\..\driver\chip\mt7687\include;..\..\..\..\..\driver\chip\inc;..\..\..\..\..\middleware\MTK\minisupp\inc;..\..\..\..\..\prebuilt\middleware\MTK\minisupp\inc;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\..\kernel\service\inc;..\..\..\..\..\middleware\third_party\lwip\ports\include;..\..\..\..\..\middleware\third_party\lwip\src\include;..\..\..\..\..\middleware\third_party\lwip\src\include\lwip;..\..\..\..\..\middleware\third_party\lwip\src\include\netif;..\..\..\..\..\middleware\MTK\nvdm\inc;..\..\..\..\..\middleware\MTK\minicli\inc;.\src\mbedtls\configs;.\src\mbedtls\include;..\..\..\..\..\middleware\third_party\lwip\src\include;..\..\..\..\..\middleware\third_party\lwip\src\include\lwip;..\..\..\..\..\middleware\third_party\lwip\ports\include;..\..\..\..\..\middleware\third_party\mbedtls\include;..\..\..\..\..\middleware\third_party\mbedtls\configs;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\..\kernel\service\inc;..\..\..\..\..\middleware\third_party\websocket;..\..\..\..\..\middleware\third_party\websocket\src;..\..\..\..\..\middleware\third_party\lwip\src\include;..\..\..\..\..\middleware\third_party\lwip\src\include\lwip;..\..\..\..\..\middleware\third_party\lwip\ports\include;..\..\..\..\..\middleware\third_party\lwip\src\include\posix;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\..\driver\chip\mt7687\inc;..\..\..\..\..\driver\chip\inc;..\..\..\..\..\middleware\MTK\dhcpd\inc;..\..\..\..\..\middleware\third_party\lwip\src\include;..\..\..\..\..\middleware\third_party\lwip\src\include\lwip;..\..\..\..\..\middleware\third_party\lwip\ports\include;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\..\middleware\MTK\wifi_service\combo\inc;..\..\..\..\..\kernel\service\inc;..\..\..\..\..\middleware\MTK\nvdm\inc;..\..\..\..\..\middleware\third_party\lwip\ports\include;..\..\..\..\..\middleware\third_party\lwip\src\include;..\..\..\..\..\middleware\MTK\wifi_stack\inc;inc;..\..\..\..\..\kernel\service\inc;..\..\..\..\..\middleware\MTK\nvdm\inc;..\..\..\..\..\middleware\MTK\wifi_stack\inc;..\..\..\..\..\middleware\MTK\wifi_service\combo\inc;..\..\..\..\..\middleware\MTK\wifi_stack\inc;..\..\..\..\..\project\linkit7697_hdk\apps\websocket_client\inc;..\..\..\..\..\driver\chip\mt7687\inc;..\..\..\..\..\driver\chip\inc;..\..\..\..\..\driver\board\linkit7697_hdk\ept\inc;.\inc;..\..\..\..\..\project\common\bsp_ex\inc;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\..\middleware\MTK\wifi_service\combo\inc;..\..\..\..\..\middleware\third_party\ping\inc;..\..\..\..\..\middleware\MTK\minicli\inc;..\..\..\..\..\driver\chip\mt7697\inc;..\..\..\..\..\prebuilt\middleware\MTK\minisupp\inc;..\..\..\..\..\prebuilt\middleware\MTK\minisupp\inc;..\..\..\..\..\middleware\MTK\wifi_service\combo\inc;..\..\..\..\..\middleware\third_party\lwip\ports\include;..\..\..\..\..\middleware\MTK\iperf\inc;..\..\..\..\..\project\common\bsp_ex\inc;..\..\..\..\..\middleware\MTK\minisupp\inc;..\..\..\..\..\prebuilt\middleware\MTK\minisupp\inc;..\..\..\..\..\middleware\MTK\nvdm\inc;..\..\..\..\..\kernel\service\inc;..\..\..\..\..\middleware\third_party\ping\inc;..\..\..\..\..\middleware\MTK\wifi_service\combo\inc;..\..\..\..\..\\kernel\service\inc;middleware\MTK\minicli\inc;..\..\..\..\..\middleware\MTK\minicli\inc;..\..\..\..\..\middleware\MTK\nvdm\inc;..\..\..\..\..\middleware\MTK\nvdm\inc_core;..\..\..\..\..\middleware\util\include;..\..\..\..\..\middleware\MTK\minicli\include;..\..\..\..\..\kernel\rtos\FreeRTOS\include;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include;..\..\..\..\..\kernel\rtos\FreeRTOS\Source;..\..\..\..\..\middleware\mlog\include;..\..\..\..\..\driver\chip\mt7697\include;..\..\..\..\..\driver\chip\inc;..\..\..\..\..\middleware\MTK\nvdm\inc;..\..\..\..\..\middleware\util\include;..\..\..\..\..\middleware\MTK\minicli\include;..\..\..\..\..\kernel\rtos\FreeRTOS\include;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include;..\..\..\..\..\kernel\rtos\FreeRTOS\Source;..\..\..\..\..\middleware\mlog\include;..\..\..\..\..\driver\chip\mt7697\include;..\..\..\..\..\driver\chip\inc;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\..\kernel\service\inc;..\..\..\..\..\kernel\service\inc;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include;..\..\..\..\..\middleware\MTK\minicli\inc;..\..\..\..\..\middleware\MTK\verno\inc
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x100000 size 0x10000
  scatter file: .\flash.sct
  link misc: --entry Reset_Handler --first __isr_vector --keep N9_array
  group lib
    ../../../../../prebuilt/driver/chip/mt7687/lib/: libhal_core_CM4_Keil.lib libhal_protected_CM4_Keil.lib
    ../../../../../prebuilt/middleware/MTK/nvdm/lib/: libnvdm_CM4_KEIL.lib
    ../../../../../prebuilt/middleware/MTK/wifi_service/combo/lib/wifi_supp/: libwifi_CM4_Keil.lib
    ../../../../../prebuilt/middleware/MTK/minisupp/lib/: libminisupp_CM4_Keil.lib
  group driver/board
    ../../../../../driver/board/linkit7697_hdk/external_flash/src/: bsp_flash_config.c
    ../../../../../driver/board/linkit7697_hdk/ept/src/: bsp_gpio_ept_config.c
  group driver/chip
    ../../../../../driver/chip/mt7687/src/common/: cos_api.c dma.c flash_sfc.c gpt.c hal_I2C.c hal_i2s_internal.c low_hal_irtx.c low_hal_pwm.c hal_gpc.c hal_gpio_7687.c hal_irrx.c hal_lp.c hal_pcnt.c hal_pinmux.c hal_spim.c hal_sys.c hal_trng.c hal_uid.c i2c.c ir_tx.c low_hal_gpio.c low_hal_irrx.c low_hal_rtc.c low_hal_wdt.c nvic.c pinmux.c pwm.c sfc.c spi_flash.c spim.c timer.c top.c uart.c
    ../../../../../driver/chip/mt7687/src/: hal_log.c hal_adc.c hal_aes.c hal_cache.c hal_cache_internal.c hal_des.c hal_eint.c hal_nvic.c hal_dwt.c hal_nvic_internal.c hal_flash.c hal_gpio.c hal_i2c_master.c hal_i2s.c hal_irtx.c hal_gdma.c hal_gpt.c hal_md5.c hal_pwm.c hal_rtc.c hal_sha.c hal_spi_master.c hal_spi_slave.c hal_uart.c hal_audio_internal_service.c hal_wdt.c hal_misc.c
  group kernel
    ../../../../../kernel/rtos/FreeRTOS/Source/: tasks.c list.c queue.c timers.c event_groups.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/RVDS/mt7687/: port_tick.c
    ../../../../../kernel/service/src/: context_info_save.c exception_handler.c mtk_HeapSizeGuard.c os_cli.c os_port_callback.c os_trace_callback.c syslog.c syslog_cli.c toi.c
    ../../../../../tools/keil/mt7687/N9/: mt76X7_n9_image.c
  group middleware/MTK/connsys
    ../../../../../middleware/MTK/connsys/src/: connsys_bus.c connsys_driver.c connsys_util.c connsys_log.c uart_slim_version.c
  group middleware/MTK/dhcpd
    ../../../../../middleware/MTK/dhcpd/src/: dhcpd.c
  group middleware/MTK/nvdm
    ../../../../../middleware/MTK/nvdm/src/: nvdm_port.c
  group middleware/MTK/wifi_service
    ../../../../../middleware/MTK/wifi_service/combo/src/: wifi_cm4_scan.c wifi_repeater.c get_profile_string.c misc.c wifi_profile.c wifi_wps.c wifi_os_api.c inband_queue_option.c
    ../../../../../middleware/MTK/wifi_service/combo/src/wifi_os_ext/: os_util.c os_utils.c
    ../../../../../middleware/MTK/wifi_service/combo/src/init/: wifi_init.c wifi_default_config.c
  group middleware/third_party/lwip
    ../../../../../middleware/third_party/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../middleware/third_party/lwip/src/core/: def.c dhcp.c dns.c inet_chksum.c init.c mem.c memp.c netif.c raw.c stats.c sys.c tcp.c tcp_in.c lwip_timers.c udp.c
    ../../../../../middleware/third_party/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c ip4.c ip4_addr.c ip_frag.c
    ../../../../../middleware/third_party/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../../../../../middleware/third_party/lwip/src/netif/: etharp.c
    ../../../../../middleware/third_party/lwip/ports/: ethernetif.c sys_arch.c lwip_log.c pbuf.c tcp_out.c
  group middleware/third_party/mbedtls
    ../../../../../middleware/third_party/mbedtls/port/: porting_layer.c
    ../../../../../middleware/third_party/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md2.c md4.c md5.c md.c md_wrap.c memory_buffer_alloc.c cmac.c ecjpake.c net_sockets.c oid.c padlock.c pem.c pk.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pk_wrap.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_srv.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c ssl_cookie.c ssl_ticket.c
  group middleware/third_party/websocket
    ../../../../../middleware/third_party/websocket/src/: librws.c rws_common.c rws_error.c rws_frame.c rws_list.c rws_memory.c rws_socketpriv.c rws_socketpub.c rws_string.c rws_thread.c
  group project/linkit7697_hdk/apps/websocket_client
    ../../../../../project/linkit7697_hdk/apps/websocket_client/src/: main.c test_librws_creation.c test_librws_socket_get_set.c wifi_lwip_helper.c network_default_config.c sys_init.c system_mt7687.c ept_gpio_var.c ept_eint_var.c
    ../src/: regions_init.c
    ../../../../.././project/linkit7697_hdk/apps/websocket_client/MDK-ARM/: startup_mt7687.s
